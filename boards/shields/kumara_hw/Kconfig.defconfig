## boards/shields/kumara_hw/Kconfig.defconfig
```kconfig
if SHIELD_KUMARA_HW

config ZMK_KEYBOARD_NAME
    default "kumara_hw"

endif # SHIELD_KUMARA_HW
```
